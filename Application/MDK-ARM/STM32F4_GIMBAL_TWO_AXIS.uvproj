# Keil uVision project STM32F4_GIMBAL_TWO_AXIS.uvproj, settings and files
target STM32F4_GIMBAL_TWO_AXIS (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4_GIMBAL_TWO_AXIS
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, HSE_VALUE=8000000
  c include: ..\Inc;..\..\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: startup_stm32f40_41xxx.s
    ../Src/: main.c system_stm32f4xx.c system_timetick.c gimbal_gpio.c gimbal_enc.c gimbal_pwm.c gimbal_adis.c gimbal_control.c gimbal_pc.c
  group STM32F4xx_StdPeriph_Driver
    ../../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_exti.c misc.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_usart.c
